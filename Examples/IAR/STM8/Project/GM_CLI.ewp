# IAR project GM_CLI.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\..\..\GM_CLI; ..\Application; ..\FW_LIB\inc; ..\Platform; ..\Queue; ..\SerialPort
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GM_CLI.srec
  ILINK.IlinkOutputFile: GM_CLI.out
  ILINK.IlinkIcfFile: C:\Users\tomfree\Desktop\test\GM_CLI\Examples\IAR\STM8\LinkerScript\link.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Application
    ../Application/: main.c stm8l15x_it.c
  group FW_LIB
    ../FW_LIB/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group GM_CLI
    ../../../../GM_CLI/: gm_cli.c
  group LinkerScript
    ../LinkerScript/: link.icf
  group Platform
    ../Platform/: delay.c platform.c
  group Queue
    ../Queue/: queue.c
  group SerialPort
    ../SerialPort/: hard_uart.c
