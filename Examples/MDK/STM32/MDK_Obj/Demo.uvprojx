# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\FW_Lib\inc;..\Platform;..\Application;..\HAL;..\GM_MultiKey;..\GM_Type;..\GM_Queue;..\GM_Memory;..\GM_Timer;..\..\..\..\GM_CLI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c app_led.c app_uart1.c app_timer3.c app_key.c
  group FW_Lib
    ../FW_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HAL
    ../HAL/: hal_uart1.c hal_timer3.c
  group Platform
    ../Platform/: stm32f10x_it.c system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group GM_MultiKey
    ../GM_MultiKey/: gm_multi_key.c
  group GM_Queue
    ../GM_Queue/: gm_queue.c
  group GM_Memory
    ../GM_Memory/: heap_1.c heap_2.c heap_3.c heap_4.c
  group GM_MultiTimer
    ../GM_Timer/: gm_timer.c
  group GM_CLI
    ../../../../GM_CLI/: gm_cli.c
software components: CMSIS:CORE 4.3.0
